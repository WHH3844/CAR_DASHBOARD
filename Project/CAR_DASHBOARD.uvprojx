# Keil uVision project CAR_DASHBOARD.uvprojx, settings and files
target CAR_DASHBOARD (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: GD32F470ZG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.5.0
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CAR_DASHBOARD +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: GD32F470
  c include: ..;..\App\Dashboard;..\App\Diag;..\App\Display;..\App\Key;..\App\Logger;..\App\Power;..\App\Sensor;..\Bsw\Communication\CanIf;..\Bsw\Communication\CanSM;..\Bsw\Communication\CanTp;..\Bsw\Communication\CanTrcv;..\Bsw\Communication\Com;..\Bsw\Communication\PduR;..\Bsw\Communication\UartIf;..\Bsw\EcuAbstraction\BacklightIf;..\Bsw\EcuAbstraction\BuzzerIf;..\Bsw\EcuAbstraction\IoHwAb;..\Bsw\EcuAbstraction\LcdIf;..\Bsw\EcuAbstraction\PowerIf;..\Bsw\EcuAbstraction\RtcIf;..\Bsw\EcuAbstraction\SdramIf;..\Bsw\EcuAbstraction\SensorIf;..\Bsw\Memory\Eep;..\Bsw\Memory\FatFsIf;..\Bsw\Memory\MemIf;..\Bsw\Memory\SdIf;..\Bsw\Memory\SdramMgr;..\Bsw\Services\BswM;..\Bsw\Services\Crc;..\Bsw\Services\Dcm;..\Bsw\Services\Dem;..\Bsw\Services\Det;..\Bsw\Services\EcuM;..\Bsw\Services\LogM;..\Bsw\Services\NvM;..\Config;..\Firmware\CMSIS;..\Firmware\CMSIS\GD\GD32F4xx\Include;..\Firmware\GD32F4xx_standard_peripheral\Include;..\Mcal\Can;..\Mcal\Dio;..\Mcal\Exmc;..\Mcal\I2c;..\Mcal\LcdTli;..\Mcal\LcdSpi;..\Mcal\Mcu;..\Mcal\Port;..\Mcal\Pwm;..\Mcal\Sdio;..\Mcal\Tim;..\Mcal\Uart;..\Mcal\Wdg;..\Os;..\Rte;..\Stub;..\Test\01_power_hold_test;..\Test\02_uart_led_test;..\Test\03_sdram_test;..\Test\04_lcd_color_test;..\Test\05_can_loop_test;..\Test\06_i2c_scan_test;..\Test\07_eeprom_test;..\Test\08_rtc_test;..\Test\09_sht30_test;..\Test\10_tf_card_test;..\Test\11_key_buzzer_test;..\Test\12_dashboard_demo
  asm define: GD32F470
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Main
    ../: main.c
  group App
    ../App/Dashboard/: App_Dashboard.c App_Dashboard.h
    ../App/Display/: App_Display.c App_Display.h
    ../App/Power/: App_Power.c App_Power.h
    ../App/Diag/: App_Diag.c App_Diag.h
    ../App/Sensor/: App_Sensor.c App_Sensor.h
    ../App/Key/: App_Key.c App_Key.h
    ../App/Logger/: App_Logger.c App_Logger.h
  group Rte
    ../Rte/: Rte.c Rte.h Rte_Signal.c Rte_Signal.h Rte_Service.c Rte_Service.h Rte_Event.c Rte_Event.h
  group Bsw_Services
    ../Bsw/Services/EcuM/: EcuM.c EcuM.h
    ../Bsw/Services/BswM/: BswM.c BswM.h
    ../Bsw/Services/Dem/: Dem.c Dem.h
    ../Bsw/Services/Det/: Det.c Det.h
    ../Bsw/Services/Dcm/: Dcm.c Dcm.h
    ../Bsw/Services/NvM/: NvM.c NvM.h
    ../Bsw/Services/Crc/: Crc.c Crc.h
    ../Bsw/Services/LogM/: LogM.c LogM.h
  group Bsw_Communication
    ../Bsw/Communication/CanIf/: CanIf.c CanIf.h
    ../Bsw/Communication/CanTp/: CanTp.c CanTp.h
    ../Bsw/Communication/PduR/: PduR.c PduR.h
    ../Bsw/Communication/Com/: Com.c Com.h
    ../Bsw/Communication/CanSM/: CanSM.c CanSM.h
    ../Bsw/Communication/CanTrcv/: CanTrcv.c CanTrcv.h
    ../Bsw/Communication/UartIf/: UartIf.c UartIf.h
  group Bsw_EcuAbstraction
    ../Bsw/EcuAbstraction/IoHwAb/: IoHwAb.c IoHwAb.h
    ../Bsw/EcuAbstraction/LcdIf/: LcdIf.c LcdIf.h
    ../Bsw/EcuAbstraction/RtcIf/: RtcIf.c RtcIf.h
    ../Bsw/EcuAbstraction/SensorIf/: SensorIf.c SensorIf.h
    ../Bsw/EcuAbstraction/BuzzerIf/: BuzzerIf.c BuzzerIf.h
    ../Bsw/EcuAbstraction/BacklightIf/: BacklightIf.c BacklightIf.h
    ../Bsw/EcuAbstraction/PowerIf/: PowerIf.c PowerIf.h
    ../Bsw/EcuAbstraction/SdramIf/: SdramIf.c SdramIf.h
  group Bsw_Memory
    ../Bsw/Memory/Eep/: Eep.c Eep.h
    ../Bsw/Memory/MemIf/: MemIf.c MemIf.h
    ../Bsw/Memory/SdIf/: SdIf.c SdIf.h
    ../Bsw/Memory/FatFsIf/: FatFsIf.c FatFsIf.h
    ../Bsw/Memory/SdramMgr/: SdramMgr.c SdramMgr.h
  group Mcal
    ../Mcal/Mcu/: Mcu.c Mcu.h
    ../Mcal/Port/: Port.c Port.h
    ../Mcal/Dio/: Dio.c Dio.h
    ../Mcal/Can/: Can.c Can.h
    ../Mcal/I2c/: I2c.c I2c.h
    ../Mcal/Uart/: Uart.c Uart.h
    ../Mcal/Sdio/: Sdio.c Sdio.h
    ../Mcal/Tim/: Tim.c Tim.h
    ../Mcal/Pwm/: Pwm.c Pwm.h
    ../Mcal/Exmc/: Exmc.c Exmc.h
    ../Mcal/LcdTli/: LcdTli.c LcdTli.h
    ../Mcal/LcdSpi/: LcdSpi.c LcdSpi.h
    ../Mcal/Wdg/: Wdg.c Wdg.h
  group Os
    ../Os/: Os.c Os.h
  group Config
    ../Config/: Mcu_Cfg.h Port_Cfg.h Can_Cfg.h Com_Cfg.h NvM_Cfg.h Dem_Cfg.h Dcm_Cfg.h Rte_Cfg.h App_Cfg.h board_pins.h gd32f4xx_libopt.h
  group Stub
    ../Stub/: Stub_Can.c Stub_Can.h Stub_Sensor.c Stub_Sensor.h Stub_Display.c Stub_Display.h Stub_NvM.c Stub_NvM.h
  group Test
    ../Test/01_power_hold_test/: 01_power_hold_test.c
    ../Test/02_uart_led_test/: 02_uart_led_test.c uart_led_test.h
    ../Test/03_sdram_test/: 03_sdram_test.c sdram_test.h
    ../Test/04_lcd_color_test/: 04_lcd_color_test.c lcd_color_test.h
    ../Test/05_can_loop_test/: 05_can_loop_test.c can_loop_test.h
    ../Test/06_i2c_scan_test/: 06_i2c_scan_test.c i2c_scan_test.h
    ../Test/07_eeprom_test/: 07_eeprom_test.c eeprom_test.h
    ../Test/08_rtc_test/: 08_rtc_test.c rtc_test.h
    ../Test/09_sht30_test/: 09_sht30_test.c sht30_test.h
    ../Test/10_tf_card_test/: 10_tf_card_test.c tf_card_test.h
    ../Test/11_key_buzzer_test/: 11_key_buzzer_test.c key_buzzer_test.h
    ../Test/12_dashboard_demo/: 12_dashboard_demo.c dashboard_demo_test.h
  group CMSIS
    ../Firmware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
    ../Firmware/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450_470.s
  group Firmware
    ../Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group Doc
    ../: 进度.md
